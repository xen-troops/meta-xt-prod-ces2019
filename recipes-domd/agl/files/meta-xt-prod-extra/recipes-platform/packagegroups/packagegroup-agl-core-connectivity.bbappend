RDEPENDS_${PN}_remove = "dhcp-server"
