RDEPENDS_${PN}_remove += " \
        packagegroup-multimedia-kernel-modules \
        packagegroup-gstreamer1.0-plugins \
"
