RDEPENDS_${PN}_remove = "dhcp-client"
